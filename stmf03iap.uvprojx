# Keil uVision project stmf03iap.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stmf03iap +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030X8
  c include: .\App;.\inc;.\src;.\STM32F0xx_StdPeriph_Driver\inc;.\User;.\CMSIS\Device\ST\STM32F0xx\Include;.\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000100 size 0x1f00
  group User
    ./User/: main.c public.c stm32f0xx_it.c
  group Std
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group App
    ./App/: Usart.c flash.c SYN480R.c
  group CMSIS
    ./CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ./CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
software components: CMSIS:CORE 5.3.0
